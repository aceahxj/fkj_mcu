# Keil uVision project fkj_mcu.uvprojx, settings and files
target fkj_mcu (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fkj_mcu +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_MD,
  c misc: --c99
  c include: ..\Driver\inc;..\ST_Lib\inc;..\System\CMSIS;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/src/: main.c delay.c systemwork.c memory.c msg.c sys_info.c cmd.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group System
    ../System/CMSIS/: system_stm32f0xx.c
    ../System/startup/: startup_stm32f0xx.s
  group Driver
    ../Driver/src/: adc.c atconfig.c bsp.c buzzerpwm.c cw2015_i2c.c flash.c i2c.c interrupt.c uart.c
